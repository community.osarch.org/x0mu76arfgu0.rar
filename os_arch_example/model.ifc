Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: model.ifc
Time: 2024-08-20T16:49:34+02:00
Written by: IfcOpenShell v0.7.0-c7830e9e5
Made in: BlenderBIM 0.0.240602-b9475d4
Authorization: Nobody

# IfcGeographicElement, Ortho IGN_ORTHO_WM_lamb
In: My Site
PredefinedType: TERRAIN
